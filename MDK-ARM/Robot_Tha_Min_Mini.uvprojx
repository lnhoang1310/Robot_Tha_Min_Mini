# Keil uVision project Robot_Tha_Min_Mini.uvprojx, settings and files
target Robot_Tha_Min_Mini (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Robot_Tha_Min_Mini +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../TMC2209_Step_Driver;../Robot;../I2C_Soft;../IMU;../UART;../Encoder_AS5600;../Distance_Sensor;../Servo_Lib;../MPU6050
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group TMC2209
    ../TMC2209_Step_Driver/: tmc2209.c
  group Robot
    ../Robot/: robot.c
  group UART
    ../UART/: uart.c response.c
  group AS5600
    ../Encoder_AS5600/: as5600.c
  group I2C_Soft
    ../I2C_Soft/: soft_i2c.c
  group BNO055
    ../IMU/: imu.c
  group Distance_Sensor
    ../Distance_Sensor/: distance_sensor.c
  group Servo
    ../Servo_Lib/: Servo.c
  group MPU6050
    ../MPU6050/: mpu6050.c
software components: CMSIS:CORE 4.3.0
